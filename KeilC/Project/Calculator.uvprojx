# Keil uVision project Calculator.uvprojx, settings and files
target calculator (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Calculator +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_LD
  c include: ..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\CMSIS\CM3\CoreSupport;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM3;..\freeRTOS
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c lcd.c stm32f10x_tim.c stm32f10x_i2c.c delay.c
  group user
    ../user/: main.c
  group freeRTOS
    ../freeRTOS/: tasks.c list.c queue.c
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
